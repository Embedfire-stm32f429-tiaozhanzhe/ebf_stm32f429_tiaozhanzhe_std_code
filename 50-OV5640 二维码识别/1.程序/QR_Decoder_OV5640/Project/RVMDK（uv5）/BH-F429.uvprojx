# Keil uVision project BH-F429.uvprojx, settings and files
target QR_DECODER (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QR_Decoder +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c misc: --c99
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\camera;..\..\User\sdram;..\..\User\usart;..\..\User\lcd;..\..\User\systick;..\..\User\beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group QR_Decoder
    ../../Libraries/QR_Decoder/: QR-Core.lib
    ../../User/: qr_decoder_user.h
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/sdram/: bsp_sdram.c
    ../../User/lcd/: bsp_lcd.c
    ../../User/font/: fonts.c
    ../../User/usart/: bsp_debug_usart.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/camera/: bsp_ov5640.c ov5640_AF.c
    ../../User/beep/: bsp_beep.c
  group DOC
    ../../: 必读说明.txt
