# Keil uVision project BH-F429.uvprojx, settings and files
target W8782_WIFI (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __FPU_PRESENT=1,ARM_MATH_CM4,STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F429xx,OS_UCOS,UCOS_V3
  c misc: --diag_suppress 1035,188,68,161,1441
  c include: ..\bsp\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\bsp\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\net\lwip\src\include\ipv4;..\net\lwip\src\include;..\net\lwip\src\arch;..\net\lwip\src;..\kernel\api\inc;..\app\inc;..\config;..\jpeg\jpeg-9a;..\net\udhcp-0.9.8;..\libmad-0.15.1b;..\net\libertas\inc;..\net\wpa;..\net\wlan_src\mlan;..\net\wlan_src\mlinux;..\net\wlan_src\user;..\net\wlan_src\mapp;..\net\wlan_src\mapp\wifidirectutl;..\kernel\ucos3\uC-CPU;..\kernel\ucos3\uC-LIB\Cfg;..\kernel\ucos3\uC-LIB\Ports;..\kernel\ucos3\uC-LIB\Source;..\drivers\stm32f4xx\inc;..\net\mosquitto-1.3.4\lib;..\kernel\ucos3\uCOS-III\Cfg;..\kernel\ucos3\uCOS-III\Ports;..\kernel\ucos3\uCOS-III\Source;..\Speex_Lib\include\speex;..\..\Speex_Lib\include;..\..\Speex_Lib\libspeex;..\net\mosquitto-1.3.4\src;..\app\inc\audio;..\..\Speex_Lib\STM32;..\..\Speex_Lib\STM32\include;..\..\Speex_Lib\STM32\libspeex;..\..\Speex_Lib\STM32\libspeex\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --remove
  group bsp
    ../bsp/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../bsp/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../bsp/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group drivers
    ../drivers/stm32f4xx/src/: usart.c driver_misc.c bsp_sdram.c dht11.c hard_timer.c key.c sdio.c bsp_spi_flash.c
  group os
    ../kernel/ucos3/uCOS-III/Cfg/: os_app_hooks.c
    ../kernel/ucos3/uCOS-III/Ports/: os_cpu_c.c os_cpu_a.s
    ../kernel/ucos3/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../kernel/ucos3/uC-CPU/: cpu_c.c cpu_core.c cpu_a.s
    ../kernel/ucos3/uC-LIB/Source/: lib_ascii.c lib_mem.c lib_str.c
  group os_api
    ../kernel/api/src/: atomic.c mbox.c msg_q.c mutex.c sem.c task.c timer.c wait.c memory.c memory2.c
  group lwip_api
    ../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ../net/lwip/src/arch/: sys_arch.c
  group lwip_core
    ../net/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c _timers.c
    ../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../net/lwip/src/netif/: ethernetif.c etharp.c eth_ethernetif.c
  group udhcp
    ../net/udhcp-0.9.8/: dhcpd.c leases.c options.c packet.c serverpacket.c
  group mlinux
    ../net/wlan_src/mlinux/: moal_main.c moal_cfg80211.c moal_debug.c moal_ioctl.c moal_proc.c moal_sdio_mmc.c moal_shim.c moal_sta_cfg80211.c moal_uap_cfg80211.c moal_uap.c moal_uap_priv.c
  group mlan
    ../net/wlan_src/mlan/: mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_init.c mlan_join.c mlan_meas.c mlan_misc.c mlan_scan.c mlan_sdio.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_sta_tx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_uap_txrx.c mlan_wmm.c
  group muser
    ../net/wlan_src/user/: skbuff.c usr_cfg.c
    ../net/wpa/: sha1.c
  group app
    ../app/src/: debug.c sys_misc.c main.c wifi.c test_wifi.c test_tcpip.c tcpapp.c webserver.c work.c test.c tcp_server.c led_ctrl.c
    ../xrf_lib/: xrf_lib_ucos3.lib
  group DOC
    ../: 必读说明.txt
software components: CMSIS:CORE 4.1.0
